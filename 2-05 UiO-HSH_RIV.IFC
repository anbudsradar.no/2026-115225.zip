Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView_V1.2], ExchangeRequirement[BuildingService]
File name: 03570_111096_1263101_RIV.ifc
Time: 2026-09-07T13:29:48
Written by: BSProLib (Ver:2024.9.0.29)
Authorization: -

# IfcProject, 1263101
LongName: 111096
MagiCAD Pset_Project - Project long name: 111096; Project name: 1263101

# IfcSite
RefLatitude: 59, 54, 44, 239196; RefLongitude: 10, 45, 0, 0; RefElevation: 0 mm
MagiCAD Pset_Site - Reference elevation: 0; Reference latitude: 59, 54, 44, 239196; Reference longitude: 10, 45, 0, 0

# IfcBuilding, 1263101
LongName: 111096
MagiCAD Pset_Building - Building long name: 111096; Building name: 1263101

# IfcBuildingStorey (5)
In: 1263101
Name | LongName = Name | Elevation (mm)
04 SYD_A-FLØY | 04 SYD_A-FLØY | 106750
Havnivå | Havnivå | 0
TAKPLAN | TAKPLAN | 113380
TEKNISK TAK A-FLØY | TEKNISK TAK A-FLØY | 110050
TEKNISK TAK VESTFLØY | TEKNISK TAK VESTFLØY | 110500

# IfcAirTerminal: JTA-2-1000 komplett (2)
In: TEKNISK TAK A-FLØY
Type - Description: Ventilation hood for air exit above roof; PredefinedType: DIFFUSER; Classification: VE3.24319 Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_AirTerminal - Description: Ventilation hood for air exit above roof; User Code: MRC.001; Manufacturer: TROX; NationalCode: VE3.24319; Productvariable1: MRC; Productvariable2: 001; Productvariable4: 4; ProductCode: JTA-2-1000 komplett; ConnectionSize_mm: ø1000; qv_SizingFlow_ls [m³/h]: 0
Group: 360.001.02 Avkast

# IfcAirTerminal: JTA-2-630 komplett
In: TEKNISK TAK A-FLØY
Type - Description: Ventilation hood for air exit above roof; PredefinedType: DIFFUSER; Classification: VE3.24319 Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_AirTerminal - Description: Ventilation hood for air exit above roof; User Code: MRC.001; Manufacturer: TROX; NationalCode: VE3.24319; Productvariable1: MRC; Productvariable2: 001; Productvariable4: 4; ProductCode: JTA-2-630 komplett; ConnectionSize_mm: ø630; qv_SizingFlow_ls [m³/h]: 0
Group: 360.001.02 Avkast

# IfcAirTerminal: KAI-4-1000
In: TEKNISK TAK A-FLØY
Type - Description: Inntak kombinasjonshatt; PredefinedType: LOUVRE; Classification: VE3.23111 Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_AirTerminal - Description: Inntak kombinasjonshatt; User Code: MRB.002; Manufacturer: TROX; NationalCode: VE3.23111; Productvariable1: MRB; Productvariable2: 002; Productvariable4: 4; ProductCode: KAI-4-1000; ConnectionSize_mm: ø1000; qv_SizingFlow_ls [m³/h]: 15000

# IfcAirTerminal: RAT-1000 (2)
In: TEKNISK TAK A-FLØY
Type - Description: Ventilation hood for air exit and intake; PredefinedType: LOUVRE; Classification: VE3.23111 Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_AirTerminal - Description: Ventilation hood for air exit and intake; User Code: MRB.002; Manufacturer: TROX; NationalCode: VE3.23111; Productvariable1: MRB; Productvariable2: 002; Productvariable4: 4; ProductCode: RAT-1000; ConnectionSize_mm: ø1000; qv_SizingFlow_ls [m³/h]: 15000
Group: 360.001.01 Inntak

# IfcAirTerminal: RAT-800
In: TEKNISK TAK A-FLØY
Type - Description: Ventilation hood for air exit and intake; PredefinedType: LOUVRE; Classification: VE3.23111 Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_AirTerminal - Description: Ventilation hood for air exit and intake; User Code: MRB.002; Manufacturer: TROX; NationalCode: VE3.23111; Productvariable1: MRB; Productvariable2: 002; Productvariable4: 4; ProductCode: RAT-800; ConnectionSize_mm: ø800; qv_SizingFlow_ls [m³/h]: 9000
Group: 360.001.01 Inntak

# IfcBuildingElementProxy (4)
Classification: Not defined (NS3420)
Name | In
CVT-630-6T IE3 | TEKNISK TAK A-FLØY
3 x CVT-630-6T IE3 | TEKNISK TAK VESTFLØY

# IfcBuildingElementProxy: ProvisionForVoid (44)
In: TEKNISK TAK A-FLØY
PredefinedType: ELEMENT; Classification: Not defined (NS3420)

# IfcDistributionSystem (9)
MagiCAD Pset_System - Code: .; System Code: .
Name | Description
370.001.04 Kjøle Tur 14° | 370.001.04 Kjøle Tur 14°
Vent | Vent
315.001.01 Overvann | 315.001.01 Overvann
360.001.05 Avtrekk | 360.001.05 Avtrekk
360.001.04 Tilluft | 360.001.04 Tilluft
320.001.05 Varme Retur 60° | 320.001.05 Varme Retur 60°
320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70°
360.001.02 Avkast | 360.001.02 Avkast
360.001.01 Inntak | 360.001.01 Inntak

# IfcDuctFitting: LBR (12)
Type - Description: Bend; PredefinedType: BEND
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Elbow - Description: Bend; Product variable 4: 2; Insulation_thickness_mm [mm]: 0; User code: KK002T
Name | In | ConnectionSize | Group
4 x LBR | TEKNISK TAK A-FLØY | 800x1600-800x1600 | 360.001.01 Inntak
LBR | TEKNISK TAK A-FLØY | 800x1800-800x1800 | 360.001.04 Tilluft
LBR | TEKNISK TAK A-FLØY | 800x1600-800x1600 | 360.001.05 Avtrekk
LBR | TEKNISK TAK A-FLØY | 800x950-800x950 | 360.001.04 Tilluft
LBR | TEKNISK TAK A-FLØY | 1600x800-950x800 | 360.001.04 Tilluft
4 x LBR | TEKNISK TAK VESTFLØY | 800x1600-800x1600 | 360.001.02 Avkast

# IfcDuctFitting: TCPU
In: TEKNISK TAK A-FLØY
Type - Description: T-stykke; PredefinedType: JUNCTION
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Branch - Description: T-stykke; Product variable 4: 2; ConnectionSize: ø500-ø500-ø400; Insulation_thickness_mm [mm]: 0; National code: VB3.14113; User code: KK002T
Group: 360.001.05 Avtrekk

# IfcDuctFitting: magicirc_elbow_full_radius_NOR (29)
In: TEKNISK TAK A-FLØY
Type - Description: Circular, smooth,R=D; PredefinedType: BEND
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Elbow - Description: Circular, smooth,R=D; Product variable 4: 2; Insulation_thickness_mm [mm]: 0; User code: KK002T
Name | ConnectionSize | Group
7 x magicirc_elbow_full_radius_NOR | ø500-ø500 | 360.001.05 Avtrekk
2 x magicirc_elbow_full_radius_NOR | ø630-ø630 | 360.001.04 Tilluft
2 x magicirc_elbow_full_radius_NOR | ø500-ø500 | 360.001.04 Tilluft
10 x magicirc_elbow_full_radius_NOR | ø315-ø315 | 360.001.05 Avtrekk
2 x magicirc_elbow_full_radius_NOR | ø315-ø315 | 360.001.04 Tilluft
2 x magicirc_elbow_full_radius_NOR | ø400-ø400 | 360.001.04 Tilluft
4 x magicirc_elbow_full_radius_NOR | ø400-ø400 | 360.001.05 Avtrekk

# IfcDuctFitting: magicirc_multi_shape_trans_001 (4)
In: TEKNISK TAK A-FLØY
Type - Description: Round to rectangular transition; PredefinedType: TRANSITION
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Reduction - Description: Round to rectangular transition; Product variable 4: 2; Insulation_thickness_mm [mm]: 0; National code: VB3; User code: KK001T
Name | ConnectionSize | Group
magicirc_multi_shape_trans_001 | 950x800-ø400 | 360.001.05 Avtrekk
magicirc_multi_shape_trans_001 | 950x800-ø400 | 360.001.04 Tilluft
magicirc_multi_shape_trans_001 | 950x800-ø630 | 360.001.04 Tilluft
magicirc_multi_shape_trans_001 | 950x800-ø500 | 360.001.04 Tilluft

# IfcDuctFitting: magicirc_reduction_NOR (7)
Type - Description: Circular, concentric and eccentric, 60 deg (short); PredefinedType: TRANSITION
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Reduction - Description: Circular, concentric and eccentric, 60 deg (short); Insulation_thickness_mm [mm]: 0; National code: VB3.16113
Name | In | ConnectionSize | Group
magicirc_reduction_NOR | TEKNISK TAK A-FLØY | ø630-ø500 | 360.001.04 Tilluft
magicirc_reduction_NOR | TEKNISK TAK A-FLØY | ø500-ø400 | 360.001.04 Tilluft
magicirc_reduction_NOR | TEKNISK TAK A-FLØY | ø710-ø630 | 360.001.05 Avtrekk
4 x magicirc_reduction_NOR | TEKNISK TAK VESTFLØY | ø710-ø630 | 360.001.05 Avtrekk

# IfcDuctFitting: magicirc_tapoutlet_001 (13)
In: TEKNISK TAK A-FLØY
Type - Description: Rectangular/circular; PredefinedType: CONNECTOR
Type - NONS_Process - NONS_Process.ProcessStatus: 200
PredefinedType: JUNCTION
MagiCAD Pset_Branch - Description: Rectangular/circular; Product variable 4: 2; Insulation_thickness_mm [mm]: 0; National code: VB3.13113; User code: KK002T
Name | ConnectionSize | Group
3 x magicirc_tapoutlet_001 | ø400-ø400 | 360.001.05 Avtrekk
3 x magicirc_tapoutlet_001 | ø400-ø400 | 360.001.04 Tilluft
4 x magicirc_tapoutlet_001 | ø315-ø315 | 360.001.05 Avtrekk
magicirc_tapoutlet_001 | ø500-ø500 | 360.001.05 Avtrekk
magicirc_tapoutlet_001 | ø200-ø200 | 360.001.04 Tilluft
magicirc_tapoutlet_001 | ø315-ø315 | 360.001.04 Tilluft

# IfcDuctFitting: magirect_outlet1_001 (7)
In: TEKNISK TAK A-FLØY
Type - Description: Rectangular/rectangular; PredefinedType: CONNECTOR
Type - NONS_Process - NONS_Process.ProcessStatus: 200
PredefinedType: JUNCTION
MagiCAD Pset_Branch - Description: Rectangular/rectangular; Product variable 4: 2; Insulation_thickness_mm [mm]: 0; National code: VB3.23112; User code: KK001T
Name | ConnectionSize | Group
magirect_outlet1_001 | 1600x800-1600x800 | 360.001.05 Avtrekk
5 x magirect_outlet1_001 | 950x800-950x800 | 360.001.05 Avtrekk
magirect_outlet1_001 | 1600x800-1600x800 | 360.001.04 Tilluft

# IfcDuctSegment: CLIMAVER Apta, A2 Apta, A1 Apta
In: Havnivå
Type - Description: CLIMAVER A2 Apta; PredefinedType: RIGIDSEGMENT; Classification: Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 275
MagiCAD Pset_Duct - Description: CLIMAVER A2 Apta; ConnectionSize_mm: 1050x1150; qv_SizingFlow_ls [m³/h]: 0; Insulation_thickness_mm [mm]: 0; Length_mm: 113747; System Classification: Undefined; System Code: .

# IfcDuctSegment: Rektangulær kanal (35)
Type - Description: Rektangulær kanal, forsinket stål; PredefinedType: RIGIDSEGMENT; Classification: VB3.21112 Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Duct - Description: Rektangulær kanal, forsinket stål; NationalCode: VB3.21112; UserCode: KK001T; Product variable 4: 2; qv_SizingFlow_ls [m³/h]: 0; Insulation_thickness_mm [mm]: 0; System Code: .
Name | In | ConnectionSize_mm | Length_mm | System Classification | Group
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 2100 | Supply Air | 360.001.04 Tilluft
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 1719 | Return Air | 360.001.05 Avtrekk
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 1416 | Supply Air | 360.001.01 Inntak
3 x Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 2848 | Supply Air | 360.001.01 Inntak
Rektangulær kanal | TEKNISK TAK A-FLØY | 1800x800 | 418 | Supply Air | 360.001.04 Tilluft
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 880 | Supply Air | 360.001.01 Inntak
Rektangulær kanal | TEKNISK TAK A-FLØY | 1800x800 | 848 | Supply Air | 360.001.04 Tilluft
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 23 | Return Air | 360.001.05 Avtrekk
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 221 | Return Air | 360.001.05 Avtrekk
Rektangulær kanal | TEKNISK TAK A-FLØY | 950x800 | 10880 | Supply Air | 360.001.04 Tilluft
Rektangulær kanal | TEKNISK TAK A-FLØY | 950x800 | 10980 | Return Air | 360.001.05 Avtrekk
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 2088 | Supply Air | 360.001.04 Tilluft
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 2537 | Return Air | 360.001.05 Avtrekk
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 2003 | Supply Air | 360.001.01 Inntak
Rektangulær kanal | TEKNISK TAK A-FLØY | 950x800 | 16680 | Supply Air | 360.001.04 Tilluft
Rektangulær kanal | TEKNISK TAK A-FLØY | 950x800 | 16500 | Return Air | 360.001.05 Avtrekk
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 2500 | Supply Air | 360.001.04 Tilluft
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 2476 | Return Air | 360.001.05 Avtrekk
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 1359 | Supply Air | 360.001.01 Inntak
Rektangulær kanal | TEKNISK TAK A-FLØY | 1600x800 | 2851 | Supply Air | 360.001.01 Inntak
2 x Rektangulær kanal | TEKNISK TAK A-FLØY | 950x800 | 247 | Return Air | 360.001.05 Avtrekk
Rektangulær kanal | TEKNISK TAK A-FLØY | 800x950 | 1379 | Supply Air | 360.001.04 Tilluft
Rektangulær kanal | TEKNISK TAK A-FLØY | 950x800 | 75 | Supply Air | 360.001.04 Tilluft
Rektangulær kanal | TEKNISK TAK A-FLØY | 950x800 | 250 | Return Air | 360.001.05 Avtrekk
Rektangulær kanal | TEKNISK TAK VESTFLØY | 1600x800 | 376 | Exhaust Air | 360.001.02 Avkast
3 x Rektangulær kanal | TEKNISK TAK VESTFLØY | 1600x800 | 1848 | Exhaust Air | 360.001.02 Avkast
Rektangulær kanal | TEKNISK TAK VESTFLØY | 1600x800 | 5 | Exhaust Air | 360.001.02 Avkast
Rektangulær kanal | TEKNISK TAK VESTFLØY | 1600x800 | 941 | Exhaust Air | 360.001.02 Avkast
Rektangulær kanal | TEKNISK TAK VESTFLØY | 1600x800 | 319 | Exhaust Air | 360.001.02 Avkast
Rektangulær kanal | TEKNISK TAK VESTFLØY | 1600x800 | 1851 | Exhaust Air | 360.001.02 Avkast

# IfcDuctSegment: Sirkulær kanal (98)
Type - Description: Sirkulær kanal, forsinket stål; PredefinedType: RIGIDSEGMENT; Classification: VB3.11113 Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Duct - Description: Sirkulær kanal, forsinket stål; NationalCode: VB3.11113; UserCode: KK002T; Product variable 4: 2; qv_SizingFlow_ls [m³/h]: 0; Insulation_thickness_mm [mm]: 0
Name | In | ConnectionSize_mm | Length_mm | System Classification | System Code | Group
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 2911 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 2898 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3571 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2715 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3570 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2683 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2787 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2480 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2590 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2806 | Return Air | . | 360.001.05 Avtrekk
4 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 1770 | Supply Air | . | 360.001.04 Tilluft
2 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2809 | Return Air | . | 360.001.05 Avtrekk
2 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3138 | Return Air | . | 360.001.05 Avtrekk
2 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2617 | Supply Air | . | 360.001.04 Tilluft
2 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2222 | Supply Air | . | 360.001.04 Tilluft
2 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3072 | Return Air | . | 360.001.05 Avtrekk
2 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2867 | Return Air | . | 360.001.05 Avtrekk
2 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2624 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 4024 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3412 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 3269 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 4025 | Return Air |  | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3580 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 3219 | Return Air |  | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 2085 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 2612 | Return Air |  | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3807 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 2365 | Return Air |  | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 3925 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3333 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 2830 | Return Air |  | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø200 | 3810 | Supply Air |  | 360.001.04 Tilluft
2 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2613 | Supply Air | . | 360.001.04 Tilluft
2 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2224 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 2715 | Return Air |  | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3300 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 3655 | Return Air |  | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 4140 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3171 | Return Air | . | 360.001.05 Avtrekk
2 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3180 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2440 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3200 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø630 | 1061 | Exhaust Air | . | 360.001.02 Avkast
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 3880 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø630 | 793 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 124 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 45 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 146 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 151 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 239 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3632 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 2220 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø630 | 75 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 1240 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 804 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 17 | Supply Air |  | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 2594 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 1085 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 1075 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 4278 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 4306 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 470 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 460 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 410 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 203 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 4060 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 2000 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 3036 | Supply Air | . | 360.001.04 Tilluft
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 222 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 1956 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 284 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 1760 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø500 | 375 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 1190 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 847 | Return Air | . | 360.001.05 Avtrekk
2 x Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 720 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 3753 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 3740 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø400 | 231 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø315 | 345 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK A-FLØY | ø630 | 1870 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK VESTFLØY | ø630 | 1591 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK VESTFLØY | ø630 | 1577 | Return Air | . | 360.001.05 Avtrekk
Sirkulær kanal | TEKNISK TAK VESTFLØY | ø630 | 1420 | Return Air | . | 360.001.05 Avtrekk

# IfcFan: Geniox 18 360.001/
In: TEKNISK TAK A-FLØY
Type - Classification: Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Fan - Product Code: Geniox 18 360.001/
Group: 360.001.05 Avtrekk; 360.001.04 Tilluft; 360.001.02 Avkast; 360.001.01 Inntak

# IfcFan: Geniox 18 360.001/alt. 1 (3)
In: TEKNISK TAK A-FLØY
Type - Classification: Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Fan - Product Code: Geniox 18 360.001/alt. 1
Group: 360.001.05 Avtrekk; 360.001.04 Tilluft; 360.001.02 Avkast; 360.001.01 Inntak

# IfcFan: Tavle_1600x500x2000
In: TEKNISK TAK A-FLØY
Type - Classification: Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 200

# IfcPipeFitting: Bend Plain EN-877_DIN-19522_NOR (5)
In: TAKPLAN
Type - Description: MA bend; PredefinedType: BEND
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Elbow - Description: MA bend; ConnectionSize: 110-110; Insulation_thickness_mm [mm]: 0; Insulation Material Code: Cellegummi
Group: 315.001.01 Overvann

# IfcPipeFitting: ELBOW-12506 (8)
Type - Description: green/blue/lilac pipe elbow SDR 6,7.4,9,11,17.6 45°, 90° ø 16–125; PredefinedType: BEND
MagiCAD Pset_Elbow - Description: green/blue/lilac pipe elbow SDR 6,7.4,9,11,17.6 45°, 90° ø 16–125; ConnectionSize: 125-125; Insulation_thickness_mm [mm]: 0
Group: 370.001.04 Kjøle Tur 14°
Name | In
6 x ELBOW-12506 | 04 SYD_A-FLØY
2 x ELBOW-12506 | TEKNISK TAK A-FLØY

# IfcPipeFitting: magi_pipe_pex_elbow_NOR (10)
In: TEKNISK TAK A-FLØY
Type - Description: MagiCAD - default bend; PredefinedType: BEND
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Elbow - Description: MagiCAD - default bend; Product variable 4: 2; ConnectionSize: 63-63; Insulation_thickness_mm [mm]: 0
Name | Group
5 x magi_pipe_pex_elbow_NOR | 320.001.05 Varme Retur 60°
5 x magi_pipe_pex_elbow_NOR | 320.002.04 Varme Tur 70°

# IfcPipeFitting: magi_pipe_pex_tee_centric_90_001 (2)
In: TEKNISK TAK A-FLØY
Type - Description: MagiCAD - default T-branch; PredefinedType: JUNCTION
Type - NONS_Process - NONS_Process.ProcessStatus: 200
MagiCAD Pset_Branch - Description: MagiCAD - default T-branch; Product variable 4: 2; ConnectionSize: 63-63-63; Insulation_thickness_mm [mm]: 0; National code: UB1.21000000
Group: 320.002.04 Varme Tur 70°

# IfcPipeSegment: Blue pipe (10)
Type - Description: Blue pipe SDR 11 (SDR 7,4 for dim 20, 25); PredefinedType: RIGIDSEGMENT; Classification: UB1.1103100016 Not defined (NS3420)
Material: BP; Group: 370.001.04 Kjøle Tur 14°
MagiCAD Pset_Heating - Material Code: BP; sets with these values: 2
MagiCAD Pset_Pipe - User Code: KRA.020; Product variable 5: 8; Product variable 4: 1; Product variable 3: mm; Product variable 2: 020; Manufacturer: Aquatherm; Material: Blue pipe; Product variable 1: KRA; NationalCode: UB1.1103100016; ConnectionSize_DN: 125; Insulation_thickness_mm [mm]: 0; SystemType: 370.001.04 Kjøle Tur 14°; Description: Blue pipe SDR 11 (SDR 7,4 for dim 20, 25); SystemClass: Hydronic Supply; Material Code: BP; MC System Code: .
Name | In | Length_mm | SystemName
Blue pipe | 04 SYD_A-FLØY | 29502 | 370.001.04 Kjøle Tur 14° 1
Blue pipe | 04 SYD_A-FLØY | 28921 | 370.001.04 Kjøle Tur 14° 2
Blue pipe | 04 SYD_A-FLØY | 445 | 370.001.04 Kjøle Tur 14° 2
Blue pipe | 04 SYD_A-FLØY | 971 | 370.001.04 Kjøle Tur 14° 2
Blue pipe | 04 SYD_A-FLØY | 910 | 370.001.04 Kjøle Tur 14° 1
Blue pipe | 04 SYD_A-FLØY | 1165 | 370.001.04 Kjøle Tur 14° 1
Blue pipe | 04 SYD_A-FLØY | 41324 | 370.001.04 Kjøle Tur 14° 1
Blue pipe | TEKNISK TAK A-FLØY | 845 | 370.001.04 Kjøle Tur 14° 2
Blue pipe | TEKNISK TAK A-FLØY | 42124 | 370.001.04 Kjøle Tur 14° 2
Blue pipe | TEKNISK TAK A-FLØY | 840 | 370.001.04 Kjøle Tur 14° 1

# IfcPipeSegment: MA (10)
In: TAKPLAN
Type - Description: Muffeløse Avløpsrør; PredefinedType: RIGIDSEGMENT; Classification: UB2.1124200021 Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 275
Material: MA
MagiCAD Pset_Heating - Material Code: MA; sets with these values: 2
MagiCAD Pset_Pipe - User Code: KNA.001; Product variable 5: 2; Product variable 4: 2; Product variable 3: mm; Product variable 2: 001; Manufacturer: Standard; Material: MA; Product variable 1: KNA; NationalCode: UB2.1124200021; ConnectionSize_DN: 110; Insulation_thickness_mm [mm]: 0; Description: Muffeløse Avløpsrør; Material Code: MA; MC System Code: .
Name | Length_mm | SystemType = Group | SystemName | SystemClass | MagiCAD Pset_Heating, Insulation Material Code = MagiCAD Pset_Pipe, Insulation Material Code
MA | 1090 | Vent | Vent 7 | Vent
MA | 454 | 315.001.01 Overvann | 315.001.01 Overvann 1 | Sanitary | Cellegummi
MA | 454 | 315.001.01 Overvann | 315.001.01 Overvann 2 | Sanitary | Cellegummi
MA | 90 | 315.001.01 Overvann | 315.001.01 Overvann 2 | Sanitary | Cellegummi
MA | 454 | 315.001.01 Overvann | 315.001.01 Overvann 4 | Sanitary | Cellegummi
MA | 90 | 315.001.01 Overvann | 315.001.01 Overvann 4 | Sanitary | Cellegummi
MA | 454 | 315.001.01 Overvann | 315.001.01 Overvann 6 | Sanitary | Cellegummi
MA | 90 | 315.001.01 Overvann | 315.001.01 Overvann 6 | Sanitary | Cellegummi
MA | 454 | 315.001.01 Overvann | 315.001.01 Overvann 8 | Sanitary | Cellegummi
MA | 90 | 315.001.01 Overvann | 315.001.01 Overvann 8 | Sanitary | Cellegummi

# IfcPipeSegment: PEX rør (19)
In: TEKNISK TAK A-FLØY
Type - Description: PEX rør som Revit stive rør; PredefinedType: RIGIDSEGMENT; Classification: UB1.21000000 Not defined (NS3420)
Type - NONS_Process - NONS_Process.ProcessStatus: 200
Material: PEX
MagiCAD Pset_Heating - Material Code: PEX; sets with these values: 2
MagiCAD Pset_Pipe - User Code: KRA.008; Product variable 5: A; Product variable 4: 2; Product variable 3: mm; Product variable 2: 008; Material: PEX rør; Product variable 1: KRA; NationalCode: UB1.21000000; ConnectionSize_DN: 63; Insulation_thickness_mm [mm]: 0; Description: PEX rør som Revit stive rør; Material Code: PEX; MC System Code: .
Name | Length_mm | SystemType = Group | SystemName | SystemClass
PEX rør | 5445 | 320.001.05 Varme Retur 60° | 320.001.05 Varme Retur 60° 18 | Hydronic Return | MagiCAD Pset_Pipe - qv_SizingFlow_ls [L/s]: 0.00000
PEX rør | 239 | 320.001.05 Varme Retur 60° | 320.001.05 Varme Retur 60° 18 | Hydronic Return | MagiCAD Pset_Pipe - qv_SizingFlow_ls [L/s]: 0.00000
PEX rør | 1100 | 320.001.05 Varme Retur 60° | 320.001.05 Varme Retur 60° 18 | Hydronic Return | MagiCAD Pset_Pipe - qv_SizingFlow_ls [L/s]: 0.00000
PEX rør | 6665 | 320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70° 2 | Hydronic Supply
PEX rør | 317 | 320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70° 2 | Hydronic Supply
PEX rør | 980 | 320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70° 2 | Hydronic Supply
PEX rør | 13634 | 320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70° 2 | Hydronic Supply
PEX rør | 3799 | 320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70° 2 | Hydronic Supply
PEX rør | 3855 | 320.001.05 Varme Retur 60° | 320.001.05 Varme Retur 60° 18 | Hydronic Return | MagiCAD Pset_Pipe - qv_SizingFlow_ls [L/s]: 0.00000
PEX rør | 20224 | 320.001.05 Varme Retur 60° | 320.001.05 Varme Retur 60° 16 | Hydronic Return | MagiCAD Pset_Pipe - qv_SizingFlow_ls [L/s]: 0.00000
PEX rør | 4619 | 320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70° 2 | Hydronic Supply
2 x PEX rør | 950 | 320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70° 2 | Hydronic Supply
PEX rør | 8322 | 320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70° 2 | Hydronic Supply
PEX rør | 3191 | 320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70° 2 | Hydronic Supply
PEX rør | 14475 | 320.001.05 Varme Retur 60° | 320.001.05 Varme Retur 60° 18 | Hydronic Return | MagiCAD Pset_Pipe - qv_SizingFlow_ls [L/s]: 0.00000
PEX rør | 2890 | 320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70° 2 | Hydronic Supply
PEX rør | 10 | 320.001.05 Varme Retur 60° | 320.001.05 Varme Retur 60° 18 | Hydronic Return | MagiCAD Pset_Pipe - qv_SizingFlow_ls [L/s]: 0.00000
PEX rør | 9 | 320.002.04 Varme Tur 70° | 320.002.04 Varme Tur 70° 2 | Hydronic Supply
